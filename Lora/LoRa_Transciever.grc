options:
  parameters:
    generate_options: qt_gui
    id: LoRa_Transciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: clk_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Gnu_Simulations\Lora\dbsnr.cf32
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("If you can risk all your winnings on one pitch and toss...")
    period: '1000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '5000000'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: 1.0+clk_offset*1e-6
    freq_offset: center_freq*clk_offset*1e-6/samp_rate
    noise_voltage: 30**(-SNRdB/20)
    seed: '0'
    taps: 1.0+0.0j
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: 'True'
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: center_freq
    impl_head: 'False'
    os_factor: '4'
    preamb_len: '8'
    sf: '7'
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: '7'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: '2'
    sf: '7'
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: '2'
    has_crc: 'True'
    impl_head: 'False'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: '2'
    ldro: '2'
    sf: '7'
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: '125000'
    frame_zero_padd: int(20*2**7*samp_rate/125000)
    preamb_len: '8'
    samp_rate: '500000'
    sf: '7'
    sync_words: '18'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_sdr_whitening_0, msg]
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_file_sink_0, '0']
- [channels_channel_model_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
